Commit message: Gaaazeboooo works lets gooooooo

File: urdf/rover_joint.urdf (robot description, URDF)
Before this commit: robot rover, 7 links, 6 joints
Links:
- link wheel_front_left: mass None -> 2
